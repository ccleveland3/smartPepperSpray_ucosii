# Keil uVision project project.uvprojx, settings and files
target Discover-More (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .;..\inc;..\..\CPU\ST\STM32\STM32F4xx_StdPeriph_Driver\inc;..\..\CPU\ST\STM32\STM32F4xx;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\MDK-ARM;..\..\uCOS-II\Source;..\..\CPU\ST\STM32\inc;..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3\MDK-ARM;..\..\uC-LIB;..\Common;..\..\FatFs_vR0.08a;..\..\LibJPEG\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: accelerometer.c app.c app_it.c audio_sample.c modem.c olaf.c selfTest.c sound_output.c system_stm32f4xx.c waverecoder.c encode.c decode.c
    ../inc/: app_cfg.h os_cfg.h
    ../Common/: libPDMFilter_Keil.lib
    ./: startup_stm32f4xx.s
  group BSP
    ../src/: bmp.c bsp.c bsp_int.c bsp_periph.c dcmi_ov9655.c LCD_Touch_Calibration.c STMPE811QTR.c
    ../inc/: bsp.h
    ../Common/: stm32f401_discovery_lsm303dlhc.c stm32f4_discovery.c stm32f4_discovery_debug.c stm32f4_discovery_lcd.c stm32f4_discovery_sdio_sd.c
  group FWL
    ../../CPU/ST/STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uC-CPU
    ../../uC-CPU/ARM-Cortex-M3/MDK-ARM/: cpu.h cpu_a.asm cpu_c.c
    ../../uC-CPU/: cpu_def.h
  group uC-OS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/MDK-ARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group readme
    ../: Readme.txt
  group FatFs
    ../../FatFs_vR0.08a/: diskio.c ff.c ffconf.h
  group LibJPEG
    ../../LibJPEG/source/: jcmainct.c jdapistd.c jddctmgr.c jfdctint.c jcmarker.c jdhuff.c jmemnobs.c jaricom.c jmemmgr.c jcmaster.c jccolor.c jcomapi.c jidctint.c jquant1.c jcparam.c jdapimin.c jdcoefct.c jfdctflt.c jcsample.c jdcolor.c jchuff.c jdinput.c jcdctmgr.c jcapimin.c jcinit.c jdmerge.c jccoefct.c jdatadst.c jcarith.c jctrans.c jidctfst.c jfdctfst.c jdarith.c jerror.c jdtrans.c jdmarker.c jdatasrc.c jdpostct.c jdsample.c jdmainct.c jcprepct.c jcapistd.c jidctflt.c jutils.c jquant2.c jdmaster.c
software components: CMSIS:CORE 4.3.0
